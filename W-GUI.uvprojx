# Keil uVision project W-GUI.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W-GUI
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\TFT_ILI9341;.\W-GUI;.\W-SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./APP/: main.c
  group ILI9341 Driver
    ./TFT_ILI9341/: tft_ili9341.c tft_ili9341.h
  group W-GUI
    ./W-GUI/: GUI_Core.c GUI_Core.h GUI.h
  group W-SYSTEM
    ./W-SYSTEM/: SYS_Core.h SYS_Core.c SYS_Device.c SYS.h SYS_Device.h SYS_Memory.c SYS_Memory.h
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Event Groups 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.1, CMSIS:RTOS2:FreeRTOS 9.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0
