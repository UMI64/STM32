# Keil uVision project system.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: system
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\SYSTEM;.\APP;.\BrushlessMotor;.\GUI;.\MathLib;.\MPU6050;.\TFT_ILI9341;.\APP\stable
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c
    ./APP/stable/: stable.c
  group SYSTEM
    ./SYSTEM/: SYS_Core.c SYS_Device.c SYS_Driver.c SYS_I2C.c SYS_Memory.c
  group MPU6050
    ./MPU6050/: mpu6050.c
  group TFT_ILI9341
    ./TFT_ILI9341/: tft_ili9341.c
  group MathLib
    ./MathLib/: ahrs.c
  group BrushlessMotor
    ./BrushlessMotor/: BrushlessMotor.c
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.1, CMSIS:RTOS2:FreeRTOS 10.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
